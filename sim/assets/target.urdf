Commit message: Tuned some control parameters

File: sim/assets/target.urdf (robot description, URDF)
Before this commit: robot target_robot, 1 links, 0 joints
Links:
- link baseLink: mass 10.0 -> 1.0; geometry collision box size=.5 .5 .5; visual mesh filename=target.obj scale=0.4 0.4 0.4
